IMAGE_INSTALL += "\
           packagegroup-qt5-machine-related \
           omxplayer \
           gstreamer1.0-omx \
            "	
