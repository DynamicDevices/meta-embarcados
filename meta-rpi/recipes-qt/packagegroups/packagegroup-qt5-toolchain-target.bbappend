
#RDEPENDS_${PN} += " \
#        vc-graphics-hardfp \
#        vc-graphics-hardfp-dev \
#"
RDEPENDS_${PN} += " \
        userland \
        userland-dev \
"
