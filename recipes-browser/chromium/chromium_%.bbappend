LDFLAGS += "-Wl,--no-keep-memory"
PARALLEL_MAKE = "-j 4"
