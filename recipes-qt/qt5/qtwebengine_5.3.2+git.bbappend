
# Original recipe sets QT_MODULE_BRANCH = "1.0" which is invalid
# Commit 21f6ce84ecca9a4ff2aa980b21d2e5174c78d14b is now on "5.5" branch

QT_MODULE_BRANCH = "5.5"
